	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R6, #4
	LDR R0, =N1
	LDR R1, =N2
	LDR R2, =DST
	ADDS R8, R2, #0xFFFFFFFF; Carry flag set to 1
BACK
	LDR R4, [R1], #4
	LDR R3, [R0], #4
	SBCS R5, R3, R4
	STR R5, [R2] , #4
	SUB R6, #1
	TEQ R6, #0
	BNE BACK 
	
STOP
	B STOP
N1 DCD 0X99999999, 0x22222222, 0x12000000, 0x1EEEEEEE
N2 DCD 0x11111111, 0x22222222, 0x33333333, 0x44444444
	AREA mydata, DATA, READWRITE
DST DCD 0,0,0,0,0,0,0,0,0,0
	END 