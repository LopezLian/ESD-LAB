	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R3, #10
	LDR R0, =N
	LDR R1, =DST
BACK
	LDR R2, [R0], #4
	ADDS R4 , R2
	ADCS R5, #0
	SUB R3, #1
	CMP R3, #0
	BNE BACK
	
	STR R4 , [R1], #4
	STR R5 , [R1]

STOP 
	B STOP
N DCD 0X12345678, 0x6A, 0x234, 0x49C, 0xEEEA13BC, 0x98765432, 0x456, 0xB654A1, 0xE12, 0xA1432
	AREA mydata, DATA, READWRITE
DST DCD 0,0,0,0,0,0,0,0,0,0
	END 